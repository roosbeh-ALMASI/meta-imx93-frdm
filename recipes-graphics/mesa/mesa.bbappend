PACKAGECONFIG:remove:class-native = "opencl"
