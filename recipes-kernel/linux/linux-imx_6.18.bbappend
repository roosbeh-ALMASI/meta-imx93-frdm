# Reproducible FRDM-i.MX93 Linux source snapshot.
SRCBRANCH = "frdm-imx93-lf-6.18.2"
KBRANCH = "${SRCBRANCH}"

SRC_URI = "git://github.com/roosbeh-ALMASI/linux-imx.git;protocol=https;branch=${SRCBRANCH}"
SRCREV = "725bbfc77d81de7788970d29b69fc8fc6e396033"
